# Keil uVision project test.uvprojx, settings and files
target test (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\App;.\CMSIS;.\STM32F10x_StdPeriph_Driver\inc;.\BSP
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./App/: delay.c main.c stm32f10x_it.c imu.c filter.c pid.c controller.c func.c
  group cm3
    ./CMSIS/: core_cm3.c system_stm32f10x.c
    ./CMSIS/startup/: startup_stm32f10x_md.s
  group lib
    ./STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group bsp
    ./BSP/: Spi.c USART.c NRF24l01.c IOI2C.c MPU6050.c eeprom.c Motor.c adc_dma.c
software components: CMSIS:CORE 4.2.0
